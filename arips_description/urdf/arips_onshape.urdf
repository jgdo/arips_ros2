Commit message: startup launch

File: arips_description/urdf/arips_onshape.urdf (robot description, URDF)
Before this commit: robot arips, 13 links, 12 joints
Joints:
- joint slider_1_0: limit lower=-10000 upper=10000 effort=1 velocity=1 -> lower=-0.5 upper=0.5 effort=1 velocity=1
